# Keil uVision project H7_MediaPlayer.uvprojx, settings and files
target H7_MediaPlayer (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H7_MediaPlayer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,STM32_THREAD_SAFE_STRATEGY=4, USE_WG=0
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../LIBJPEG/App;../LIBJPEG/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/LibJPEG/include;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Applications/ANSI_Art;../Applications/Audio;../Applications/Audio/decoder;../Applications/Audio/lyric;../Applications/Audio/ui;../Applications/letter_shell;../Applications/letter_shell/fs_support;../Applications/letter_shell/game;../Applications/letter_shell/game/ASCII_Patrol;../Applications/letter_shell/game/snake;../Applications/letter_shell/log;../Applications/letter_shell/shell_enhance;../Applications/letter_shell/src;../Applications/lvgl;../Applications/W25Q64;../Applications/XY_Modem;../Drivers/User/BOOT;../Drivers/User/DR_LIBS;../Drivers/User/FS_MISC;../Drivers/User/LCD;../Drivers/User/LVGL/src;../Drivers/User/OS_MISC;../Drivers/User/RTOS;../Drivers/User/W25QXX/interface;../Drivers/User/W25QXX/src;../Drivers/User/XYMODEM
  asm include: ../Core/Inc;../FATFS/Target;../FATFS/App;../LIBJPEG/App;../LIBJPEG/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/LibJPEG/include;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\stm32h723xg_flash.sct
  link misc: --keep shellCommand*
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c bdma.c crc.c dma.c dma2d.c iwdg.c octospi.c sai.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/LIBJPEG/App
    ../LIBJPEG/App/: libjpeg.c
  group Application/User/LIBJPEG/Target
    ../LIBJPEG/Target/: jdata_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_ospi.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
  group ansi_art
    ../Applications/ANSI_Art/: Art_Data.c Art_show.c
  group auido
    ../Applications/Audio/decoder/: audio_flac.c audio_mp3.c audio_wav.c
    ../Applications/Audio/lyric/: audio_lrc.c
    ../Applications/Audio/ui/: audio_tui.c
    ../Applications/Audio/: audio_port.c
  group littershell
    ../Applications/letter_shell/fs_support/: shell_fs.c
    ../Applications/letter_shell/log/: log.c
    ../Applications/letter_shell/shell_enhance/: shell_cmd_group.c
    ../Applications/letter_shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../Applications/letter_shell/: shell_port.c
  group games
    ../Applications/letter_shell/game/2048/: 2048.c
    ../Applications/letter_shell/game/ASCII_Patrol/: assets.cpp conf.cpp game_ap.cpp gameover.cpp inter.cpp manual.cpp menu.cpp spec_mcu.cpp temp.cpp twister.cpp
    ../Applications/letter_shell/game/snake/: snake.c snake_tiny.c
    ../Applications/letter_shell/game/: game.c
  group lvgl
    ../Applications/lvgl/: lvgl_port.c lvgl_user.c
  group xy_modem
    ../Applications/XY_Modem/: xymodem_port.c
    ../Drivers/User/XYMODEM/: xymodem.c
  group boot
    ../Drivers/User/BOOT/: boot.c
  group fs_misc
    ../Drivers/User/FS_MISC/: cat.c hexdump.c
  group lcd
    ../Drivers/User/LCD/: lcd_port.c lcd_spi_154.c
  group os_misc
    ../Drivers/User/OS_MISC/: get_res.c message.c
  group rtos
    ../Drivers/User/RTOS/: rtos_utils.c
  group w25qxx
    ../Applications/W25Q64/: driver_w25qxx_interface.c w25q64_port.c
    ../Drivers/User/W25QXX/src/: driver_w25qxx.c
software components: CMSIS:CORE 4.3.0
